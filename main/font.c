/* SPDX-License-Identifier: GPL-3.0-or-later */
/**
 * @file font.c
 * @brief The glyphs: seven rows of five bits each, the high bit on the left.
 */
#include "font.h"


typedef struct { char c; uint8_t rows[FONT_H]; } glyph_t;

static const glyph_t GLYPHS[] = {
    { '0', { 0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E } }, { '1', { 0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E } },
    { '2', { 0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F } }, { '3', { 0x1F, 0x02, 0x04, 0x02, 0x01, 0x11, 0x0E } },
    { '4', { 0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02 } }, { '5', { 0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E } },
    { '6', { 0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E } }, { '7', { 0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08 } },
    { '8', { 0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E } }, { '9', { 0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C } },
    { 'A', { 0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11 } }, { 'B', { 0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E } },
    { 'C', { 0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E } }, { 'D', { 0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0x1C } },
    { 'E', { 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F } }, { 'F', { 0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10 } },
    { 'G', { 0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F } }, { 'H', { 0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11 } },
    { 'I', { 0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E } }, { 'J', { 0x07, 0x02, 0x02, 0x02, 0x02, 0x12, 0x0C } },
    { 'K', { 0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11 } }, { 'L', { 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F } },
    { 'M', { 0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11 } }, { 'N', { 0x11, 0x11, 0x19, 0x15, 0x13, 0x11, 0x11 } },
    { 'O', { 0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E } }, { 'P', { 0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10 } },
    { 'Q', { 0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D } }, { 'R', { 0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11 } },
    { 'S', { 0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E } }, { 'T', { 0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04 } },
    { 'U', { 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E } }, { 'V', { 0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04 } },
    { 'W', { 0x11, 0x11, 0x11, 0x15, 0x15, 0x15, 0x0A } }, { 'X', { 0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11 } },
    { 'Y', { 0x11, 0x11, 0x11, 0x0A, 0x04, 0x04, 0x04 } }, { 'Z', { 0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F } },
    { '.', { 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0C } }, { ':', { 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00 } },
    { '!', { 0x04, 0x04, 0x04, 0x04, 0x04, 0x00, 0x04 } }, { '/', { 0x01, 0x01, 0x02, 0x04, 0x08, 0x10, 0x10 } },
    { '-', { 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00 } }, { '\'', { 0x04, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00 } },
    { 'x', { 0x00, 0x00, 0x11, 0x0A, 0x04, 0x0A, 0x11 } }, { '%', { 0x18, 0x19, 0x02, 0x04, 0x08, 0x13, 0x03 } },
    { '#', { 0x0A, 0x0A, 0x1F, 0x0A, 0x1F, 0x0A, 0x0A } }, { '+', { 0x00, 0x04, 0x04, 0x1F, 0x04, 0x04, 0x00 } },
    { '=', { 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00 } }, { '?', { 0x0E, 0x11, 0x01, 0x02, 0x04, 0x00, 0x04 } },
};

static const uint8_t *glyph(char c)
{
    if ( ('a' <= c) && ('z' >= c) && ('x' != c) )
    {
        c = (char)(c - 'a' + 'A');
    }
    for ( unsigned i = 0; sizeof GLYPHS / sizeof GLYPHS[0] > i; i++ )
    {
        if ( GLYPHS[i].c == c )
        {
            return GLYPHS[i].rows;
        }
    }
    return 0;
}

int font_width(const char *text, int scale)
{
    int n = 0;
    for ( const char *p = text; *p; p++ )
    {
        n++;
    }
    if ( 0 == n )
    {
        return 0;
    }
    return (n * (FONT_W + 1) - 1) * scale;
}

static void rect(uint16_t *fb, int fb_w, int fb_h, int x0, int y0, int x1, int y1, uint16_t c)
{
    if ( 0 > x0 )
    {
        x0 = 0;
    }
    if ( 0 > y0 )
    {
        y0 = 0;
    }
    if ( fb_w < x1 )
    {
        x1 = fb_w;
    }
    if ( fb_h < y1 )
    {
        y1 = fb_h;
    }
    for ( int y = y0; y1 > y; y++ )
    {
        for ( int x = x0; x1 > x; x++ )
        {
            fb[y * fb_w + x] = c;
        }
    }
}

void font_draw(uint16_t *fb, int fb_w, int fb_h, int x, int y, const char *text, int scale, uint16_t colour,
               uint16_t outline)
{
    /* Two passes over the lit cells: each one a square one pixel bigger all
     * round in the outline's colour, then each one in the letter's. */
    int first = 0;
    if ( outline == colour )
    {
        first = 1;
    }
    for ( int pass = first; 2 > pass; pass++ )
    {
        int grow = 1;
        uint16_t paint = outline;
        if ( pass )
        {
            grow = 0;
            paint = colour;
        }
        int cx = x;
        for ( const char *p = text; *p; p++, cx += (FONT_W + 1) * scale )
        {
            const uint8_t *g = glyph(*p);
            if ( !g )
            {
                continue;
            }
            for ( int gy = 0; FONT_H > gy; gy++ )
            {
                for ( int gx = 0; FONT_W > gx; gx++ )
                {
                    if ( !((g[gy] >> (FONT_W - 1 - gx)) & 1) )
                    {
                        continue;
                    }
                    const int X = cx + gx * scale, Y = y + gy * scale;
                    rect(fb, fb_w, fb_h, X - grow, Y - grow, X + scale + grow, Y + scale + grow, paint);
                }
            }
        }
    }
}

void font_draw_centred(uint16_t *fb, int fb_w, int fb_h, int cx, int y, const char *text, int scale, uint16_t colour,
                       uint16_t outline)
{
    font_draw(fb, fb_w, fb_h, cx - font_width(text, scale) / 2, y, text, scale, colour, outline);
}
